<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>FreeRTOS-8.2.1</name>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\portable\MemMang\heap_1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F\portmacro.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib\freertos-8.2.1\timers.c</name>
    </file>
  </group>
  <group>
    <name>PeriphLib-1.5.1</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_cec.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_cryp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_dcmi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_dma2d.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_flash_ramfunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_fmpi2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_fsmc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_hash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_ltdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_qspi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_rng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_sai.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_sdio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_spdifrx.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc\stm32f4xx_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_dma2d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_fmpi2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_ltdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_qspi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_sai.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_spdifrx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\src\stm32f4xx_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>SscpLib</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\lib\drivers\canrouter.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\drivers\catalog.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\drivers\pin.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\lib\drivers\canrouter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\drivers\catalog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\drivers\pin.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\inc\bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\inc\FreeRTOSConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\inc\stm32f4xx_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\inc\stm32f4xx_it.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\starter_bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\CMSIS-F4-1.5.1\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f40_41xxx.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\system_stm32f4xx.c</name>
      </file>
    </group>
  </group>
</project>


