# IAR project protobuf_test_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ../lib/cpputest; ../lib/drivers; ../lib/protobuf
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: protobuf_test_test.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ../lib/cpputest/: cpputest.a
  group SscpLib/inc
    ../lib/protobuf/: lib_pb.h pb.h pb_decode.h pb_encode.h test.pb.h test2.pb.h
  group SscpLib/src
    ../lib/protobuf/: lib_pb.c pb_common.c pb_decode.c pb_encode.c test.pb.c test2.pb.c
  group tests
    tests/: AllTests.cpp CodeTest.cpp
