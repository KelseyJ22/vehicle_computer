# IAR project vehicle_computer_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; STM32F40_41xxx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ../lib/cpputest; src; inc; ..\lib\CMSIS-F4-1.5.1\Include; ..\lib\CMSIS-F4-1.5.1\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc; ..\lib\freertos-8.2.1\include; ..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F; ..\lib\drivers; ..\lib\protobuf
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    tests/: AllTests.cpp driveControlsTests.cpp
    inc/: app_drive.h dev_tritium.h
    ../lib/cpputest/: cpputest.a
