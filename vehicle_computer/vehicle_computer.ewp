# IAR project vehicle_computer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; STM32F40_41xxx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: $PROJ_DIR$; src\; inc\; ..\lib\CMSIS-F4-1.5.1\Include; ..\lib\CMSIS-F4-1.5.1\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver-1.5.1\inc; ..\lib\freertos-8.2.1\include; ..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F; ..\lib\drivers; ..\lib\protobuf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; inc; src; ..\lib\CMSIS-F4-1.5.1\Include; ..\lib\CMSIS-F4-1.5.1\Device\ST\STM32F4xx\Include; ..\lib\freertos-8.2.1\portable\IAR\ARM_CM4F; ..\lib\drivers
  OBJCOPY.OOCOutputFile: vehicle_computer.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group FreeRTOS-8.2.1
    ../lib/freertos-8.2.1/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../lib/freertos-8.2.1/portable/MemMang/: heap_1.c
    ../lib/freertos-8.2.1/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group PeriphLib-1.5.1/inc
    ../lib/STM32F4xx_StdPeriph_Driver-1.5.1/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group PeriphLib-1.5.1/src
    ../lib/STM32F4xx_StdPeriph_Driver-1.5.1/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SscpLib/inc
    ../lib/drivers/: canrouter.h catalog.h pin.h
    ../lib/protobuf/: lib_pb.h lib_protobuf_data_struct.h lib_protobuf_utils.h
  group SscpLib/src
    ../lib/drivers/: canrouter.c catalog.c pin.c
    ../lib/protobuf/: lib_pb.c lib_protobuf_data_struct.c lib_protobuf_utils.c
  group User/inc
    inc/: bsp.h FreeRTOSConfig.h global.h stm32f4xx_conf.h stm32f4xx_it.h
  group User/inc/app
    inc/: app_drive.h app_ethernet.h app_imu_accelerometer.h app_imu_gyroscope.h app_imu_magnetometer.h app_pedals.h app_send_data.h
  group User/inc/dev
    inc/: dev_adc.h dev_drive_config.h dev_imu.h dev_tritium.h
  group User/src
    src/: main.c starter_bsp.c stm32f4xx_it.c system_stm32f4xx.c
    ../lib/CMSIS-F4/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group User/src/app
    src/: app_cruise_control.c app_drive.c app_ethernet.c app_imu_accelerometer.c app_imu_gyroscope.c app_imu_magnetometer.c app_pedals.c app_send_data.c
  group User/src/dev
    src/: dev_adc.c dev_drive_config.c dev_imu.c dev_tritium.c
